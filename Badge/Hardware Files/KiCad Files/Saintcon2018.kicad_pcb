# Repository compukidmike/Saintcon2018

File README.md:

# Saintcon2018
Here's all the info you need about the 2018 Saintcon badge. You'll find badge building and flashing instructions as well as how to operate it. The Minibadges folder has info for minibadge makers.

NOTE: Female headers will be provided with the main badge this year, so minbadge makers do not need to provide their own.

## KiCad design Badge/Hardware Files/KiCad Files/Saintcon2018.kicad_pcb

File Badge/Readme.md:

# About the Badge
This year's badge features an ESP32 WiFi module running MicroPython. It has an 8x32 LED matrix display, 3 buttons, and 12 minibadge spots, as well as a rechargeable battery.
# Badge Instructions
## Building your badge
[BadgeBuildSheet.pdf](https://github.com/compukidmike/Saintcon2018/blob/master/Badge/BadgeBuildSheet.pdf) has instructions on how to assemble your badge
## Flashing your badge
You'll need some software to flash the code on your badge. 
The first thing you'll need is Python 3. This can be downloaded from https://www.python.org/downloads/
Once you have python installed, open a terminal/command prompt and run the following command: **pip install esptool**
You now have the tools you need to flash the code on your badge. Download **Saintcon2018.bin** from this github repository. 
Next, you will need to place the LOLIN D32 board into a mode where you can flash it's code.  To do this, you must pull GPIO pin 0 to ground.  This is best done by placing the LOLIN D32 board into a breadboard and pulling GPIO pin 0 to ground with a jumper wire.
Then, in a terminal window, navigate to the location of the badge firmware file, and run the following command, substituting the COM5 for the name of your badge serial port (this will vary depending on OS): **python esptool.py --port COM5 --baud 460800 write_flash --flash_size=detect 0 Saintcon2018.bin**

## Charging Your Badge
Simply use a microUSB cable to connect the badge to a USB power source (computer, phone charger, etc). This will power the badge as well as charge the battery.
The badge doesn't have an On/Off switch, so unplug the battery when you're not using it.

## Using Your Badge
The badge has 3 buttons labeled UP, DOWN, and SELECT. When first turned on, the badge is in display mode. Pressing the Up/Down buttons will cycle through the different displays. They are: SAINTCON, Custom Message, Hacker Challenge Score, Hacker Challenge ID.
 
Pressing Select will take you into the menu. The options here are: Brightness, Wifi Status, Wifi Config, Minibadges, Back. 
- Selecting Brightness will allow you to change the brightness of the LED matrix. 
- Selecting Wifi Status will show you if the wifi is connected or not. 
- Selecting Wifi Config will start the badge wifi configuration access point. In this mode, the display will show you the SSID and Password for the network that is being created by the badge. Connecting to that wifi network with your computer or phone will allow you to change badge settings like the wifi network that the badge connects to as well as the Custom Message. 
- Selecting Back will take you back to display mode.
 
Connecting your badge to a computer will allow you to do much more than the simple menu system allows, which brings us to...

## Editing Badge Code
To edit the badge code, I suggest an IDE called uPyCraft. It can be downloaded from http://docs.dfrobot.com/upycraft/ 
There are links on that page to tutorials on using the software.
One of the nice things about MicroPython is that the source code is all contained within the device, so you don't need to download the source to get started editing. uPyCraft can directly edit the files on the module.

Parts:
C1, C2, C9, C12, C13: 1uF; C_0603
C3, C4, C10: 0.1uF; C_0603
C11: CP_Small; CP_Elec_5x5.3
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180, D181, D182, D183, D184, D185, D186, D187, D188, D189, D190, D191, D192, D193, D194, D195, D196, D197, D198, D199, D200, D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225, D226, D227, D228, D229, D230, D231, D232, D233, D234, D235, D236, D237, D238, D239, D240, D241, D242, D243, D244, D245, D246, D247, D248, D249, D250, D251, D252, D253, D254, D255, D256: LED; LED_0603_1608Metric
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: SAINTCON-Minibadge; SAINTCON-Minibadge-Shiny
R1, R2, R4, R5: 4.7k; R_0603
R3, R6, R7: 100k; R_0603
SW1, SW2, SW3: SW_Push; SW_SPST_PTS645
U1: LolinD32; Lolin D32
U2, U3: IS31FL3730; QFN-24_EP_4x4_Pitch0.5mm
U4: AP22802AW5-7; SOT-23-5
U5: AP2112K-3.3TRG1; SOT-23-5

Connections:
+3V3: C13.1, J1.7, J1.15, J2.7, J2.15, J3.7, J3.15, J4.7, J4.15, J5.7, J5.15, J6.7, J6.15, J7.7, J7.15, J8.7, J8.15, J9.7, J9.15, J10.7, J10.15, J11.7, J11.15, J12.7, J12.15, R6.1, U5.5 (VOUT)
+5V: C10.1, C11.1, C12.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, U4.1 (VOUT), U5.1 (VIN), U5.3 (EN)
+BATT: C1.1, C2.1, C3.1, C4.1, C9.1, U1.1 (BAT), U2.11 (VCC), U3.11 (VCC), U4.5 (VIN)
C1-1: D1.1 (K), D9.2 (A), D33.1 (K), D41.2 (A), D65.1 (K), D73.2 (A), D97.1 (K), D105.2 (A), D129.1 (K), D137.2 (A), D161.1 (K), D169.2 (A), D193.1 (K), D201.2 (A), D225.1 (K), D233.2 (A), U2.24 (C1)
C1-2: D17.1 (K), D25.2 (A), D49.1 (K), D57.2 (A), D81.1 (K), D89.2 (A), D113.1 (K), D121.2 (A), D145.1 (K), D153.2 (A), D177.1 (K), D185.2 (A), D209.1 (K), D217.2 (A), D241.1 (K), D249.2 (A), U3.24 (C1)
C2-1: D2.1 (K), D10.2 (A), D34.1 (K), D42.2 (A), D66.1 (K), D74.2 (A), D98.1 (K), D106.2 (A), D130.1 (K), D138.2 (A), D162.1 (K), D170.2 (A), D194.1 (K), D202.2 (A), D226.1 (K), D234.2 (A), U2.23 (C2)
C2-2: D18.1 (K), D26.2 (A), D50.1 (K), D58.2 (A), D82.1 (K), D90.2 (A), D114.1 (K), D122.2 (A), D146.1 (K), D154.2 (A), D178.1 (K), D186.2 (A), D210.1 (K), D218.2 (A), D242.1 (K), D250.2 (A), U3.23 (C2)
C3-1: D3.1 (K), D11.2 (A), D35.1 (K), D43.2 (A), D67.1 (K), D75.2 (A), D99.1 (K), D107.2 (A), D131.1 (K), D139.2 (A), D163.1 (K), D171.2 (A), D195.1 (K), D203.2 (A), D227.1 (K), D235.2 (A), U2.22 (C3)
C3-2: D19.1 (K), D27.2 (A), D51.1 (K), D59.2 (A), D83.1 (K), D91.2 (A), D115.1 (K), D123.2 (A), D147.1 (K), D155.2 (A), D179.1 (K), D187.2 (A), D211.1 (K), D219.2 (A), D243.1 (K), D251.2 (A), U3.22 (C3)
C4-1: D4.1 (K), D12.2 (A), D36.1 (K), D44.2 (A), D68.1 (K), D76.2 (A), D100.1 (K), D108.2 (A), D132.1 (K), D140.2 (A), D164.1 (K), D172.2 (A), D196.1 (K), D204.2 (A), D228.1 (K), D236.2 (A), U2.21 (C4)
C4-2: D20.1 (K), D28.2 (A), D52.1 (K), D60.2 (A), D84.1 (K), D92.2 (A), D116.1 (K), D124.2 (A), D148.1 (K), D156.2 (A), D180.1 (K), D188.2 (A), D212.1 (K), D220.2 (A), D244.1 (K), D252.2 (A), U3.21 (C4)
C5-1: D5.1 (K), D13.2 (A), D37.1 (K), D45.2 (A), D69.1 (K), D77.2 (A), D101.1 (K), D109.2 (A), D133.1 (K), D141.2 (A), D165.1 (K), D173.2 (A), D197.1 (K), D205.2 (A), D229.1 (K), D237.2 (A), U2.19 (C5)
C5-2: D21.1 (K), D29.2 (A), D53.1 (K), D61.2 (A), D85.1 (K), D93.2 (A), D117.1 (K), D125.2 (A), D149.1 (K), D157.2 (A), D181.1 (K), D189.2 (A), D213.1 (K), D221.2 (A), D245.1 (K), D253.2 (A), U3.19 (C5)
C6-1: D6.1 (K), D14.2 (A), D38.1 (K), D46.2 (A), D70.1 (K), D78.2 (A), D102.1 (K), D110.2 (A), D134.1 (K), D142.2 (A), D166.1 (K), D174.2 (A), D198.1 (K), D206.2 (A), D230.1 (K), D238.2 (A), U2.18 (C6)
C6-2: D22.1 (K), D30.2 (A), D54.1 (K), D62.2 (A), D86.1 (K), D94.2 (A), D118.1 (K), D126.2 (A), D150.1 (K), D158.2 (A), D182.1 (K), D190.2 (A), D214.1 (K), D222.2 (A), D246.1 (K), D254.2 (A), U3.18 (C6)
C7-1: D7.1 (K), D15.2 (A), D39.1 (K), D47.2 (A), D71.1 (K), D79.2 (A), D103.1 (K), D111.2 (A), D135.1 (K), D143.2 (A), D167.1 (K), D175.2 (A), D199.1 (K), D207.2 (A), D231.1 (K), D239.2 (A), U2.17 (C7)
C7-2: D23.1 (K), D31.2 (A), D55.1 (K), D63.2 (A), D87.1 (K), D95.2 (A), D119.1 (K), D127.2 (A), D151.1 (K), D159.2 (A), D183.1 (K), D191.2 (A), D215.1 (K), D223.2 (A), D247.1 (K), D255.2 (A), U3.17 (C7)
C8-1: D8.1 (K), D16.2 (A), D40.1 (K), D48.2 (A), D72.1 (K), D80.2 (A), D104.1 (K), D112.2 (A), D136.1 (K), D144.2 (A), D168.1 (K), D176.2 (A), D200.1 (K), D208.2 (A), D232.1 (K), D240.2 (A), U2.16 (C8)
C8-2: D24.1 (K), D32.2 (A), D56.1 (K), D64.2 (A), D88.1 (K), D96.2 (A), D120.1 (K), D128.2 (A), D152.1 (K), D160.2 (A), D184.1 (K), D192.2 (A), D216.1 (K), D224.2 (A), D248.1 (K), D256.2 (A), U3.16 (C8)
EN: R7.1, U1.18 (23), U4.4 (EN)
FLG: R6.2, U1.23 (19), U4.3 (FLG)
GND: C1.2, C2.2, C3.2, C4.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.2, J1.8, J1.16, J2.2, J2.8, J2.16, J3.2, J3.8, J3.16, J4.2, J4.8, J4.16, J5.2, J5.8, J5.16, J6.2, J6.8, J6.16, J7.2, J7.8, J7.16, J8.2, J8.8, J8.16, J9.2, J9.8, J9.16, J10.2, J10.8, J10.16, J11.2, J11.8, J11.16, J12.2, J12.8, J12.16, R3.2, R7.2, SW1.2, SW2.2, SW3.2, U1.17 (GND), U1.32 (GND), U2.6 (AD), U2.20 (GND), U2.25 (PAD), U3.20 (GND), U3.25 (PAD), U4.2 (GND), U5.2 (GND)
unnamed: R1.1, R2.1, R4.1, R5.1, U1.16 (3V)
R1-1: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U2.7 (R1)
R1-2: D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), U3.7 (R1)
R2-1: D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U2.8 (R2)
R2-2: D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), U3.8 (R2)
R3-1: D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), U2.9 (R3)
R3-2: D81.2 (A), D82.2 (A), D83.2 (A), D84.2 (A), D85.2 (A), D86.2 (A), D87.2 (A), D88.2 (A), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), U3.9 (R3)
R4-1: D97.2 (A), D98.2 (A), D99.2 (A), D100.2 (A), D101.2 (A), D102.2 (A), D103.2 (A), D104.2 (A), D105.1 (K), D106.1 (K), D107.1 (K), D108.1 (K), D109.1 (K), D110.1 (K), D111.1 (K), D112.1 (K), U2.10 (R4)
R4-2: D113.2 (A), D114.2 (A), D115.2 (A), D116.2 (A), D117.2 (A), D118.2 (A), D119.2 (A), D120.2 (A), D121.1 (K), D122.1 (K), D123.1 (K), D124.1 (K), D125.1 (K), D126.1 (K), D127.1 (K), D128.1 (K), U3.10 (R4)
R5-1: D129.2 (A), D130.2 (A), D131.2 (A), D132.2 (A), D133.2 (A), D134.2 (A), D135.2 (A), D136.2 (A), D137.1 (K), D138.1 (K), D139.1 (K), D140.1 (K), D141.1 (K), D142.1 (K), D143.1 (K), D144.1 (K), U2.12 (R5)
R5-2: D145.2 (A), D146.2 (A), D147.2 (A), D148.2 (A), D149.2 (A), D150.2 (A), D151.2 (A), D152.2 (A), D153.1 (K), D154.1 (K), D155.1 (K), D156.1 (K), D157.1 (K), D158.1 (K), D159.1 (K), D160.1 (K), U3.12 (R5)
R6-1: D161.2 (A), D162.2 (A), D163.2 (A), D164.2 (A), D165.2 (A), D166.2 (A), D167.2 (A), D168.2 (A), D169.1 (K), D170.1 (K), D171.1 (K), D172.1 (K), D173.1 (K), D174.1 (K), D175.1 (K), D176.1 (K), U2.13 (R6/C11)
R6-2: D177.2 (A), D178.2 (A), D179.2 (A), D180.2 (A), D181.2 (A), D182.2 (A), D183.2 (A), D184.2 (A), D185.1 (K), D186.1 (K), D187.1 (K), D188.1 (K), D189.1 (K), D190.1 (K), D191.1 (K), D192.1 (K), U3.13 (R6/C11)
R7-1: D193.2 (A), D194.2 (A), D195.2 (A), D196.2 (A), D197.2 (A), D198.2 (A), D199.2 (A), D200.2 (A), D201.1 (K), D202.1 (K), D203.1 (K), D204.1 (K), D205.1 (K), D206.1 (K), D207.1 (K), D208.1 (K), U2.14 (R7/C10)
R7-2: D209.2 (A), D210.2 (A), D211.2 (A), D212.2 (A), D213.2 (A), D214.2 (A), D215.2 (A), D216.2 (A), D217.1 (K), D218.1 (K), D219.1 (K), D220.1 (K), D221.1 (K), D222.1 (K), D223.1 (K), D224.1 (K), U3.14 (R7/C10)
R8-1: D225.2 (A), D226.2 (A), D227.2 (A), D228.2 (A), D229.2 (A), D230.2 (A), D231.2 (A), D232.2 (A), D233.1 (K), D234.1 (K), D235.1 (K), D236.1 (K), D237.1 (K), D238.1 (K), D239.1 (K), D240.1 (K), U2.15 (R8/C9)
R8-2: D241.2 (A), D242.2 (A), D243.2 (A), D244.2 (A), D245.2 (A), D246.2 (A), D247.2 (A), D248.2 (A), D249.1 (K), D250.1 (K), D251.1 (K), D252.1 (K), D253.1 (K), D254.1 (K), D255.1 (K), D256.1 (K), U3.15 (R8/C9)
SCL: R2.2, U1.8 (26), U2.2 (SCL), U3.2 (SCL), U3.6 (AD)
SCL2: J1.13, J2.13, J3.13, J4.13, J5.13, J6.13, J7.13, J8.13, J9.13, J10.13, J11.13, J12.13, R5.2, U1.19 (22)
SDA: R1.2, U1.9 (25), U2.1 (SDA), U3.1 (SDA)
SDA2: J1.14, J2.14, J3.14, J4.14, J5.14, J6.14, J7.14, J8.14, J9.14, J10.14, J11.14, J12.14, R4.2, U1.22 (21)
SDB: R3.1, U1.7 (27), U2.3 (SDB), U3.3 (SDB)
SW1: SW1.1, U1.27 (16)
SW2: SW2.1, U1.26 (17)
SW3: SW3.1, U1.24 (18)

Board: 2 copper layers, 94.0 x 154.2 mm, 292 parts (0 on the bottom side), 47 nets.

## Commit log

2018-09-28 Add badge source code
2018-09-29 add frozen modules
2019-11-03 new statuses and types for minibadge/minibadge communication
2019-11-03 Broadcast messages and events
2019-11-03 fix typos in markdown rendering
2019-11-03 cleaner wording
2022-11-14 Improved instructions for flashing the board.
